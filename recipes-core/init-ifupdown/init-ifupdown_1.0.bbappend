FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}-${PV}:"

PR .= ".2"

